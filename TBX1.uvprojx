# Keil uVision project TBX1.uvprojx, settings and files
target TBX1 (6160000::V6.16::ARMCLANG)
  device: M032SG8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: TBX1 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc;.\CODE;..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../Library/StdDriver/src/: adc.c clk.c crc.c fmc.c gpio.c i2c.c pdma.c retarget.c rtc.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
  group User
    ./CODE/: clk_conf.c int_handler.c main.c periph_conf.c pin_conf.c key.c sw_buf.c counter.c user.c
  group USBD
    ./USBD/: descriptors.c usbd_class.c
software components: CMSIS:CORE 5.5.0
